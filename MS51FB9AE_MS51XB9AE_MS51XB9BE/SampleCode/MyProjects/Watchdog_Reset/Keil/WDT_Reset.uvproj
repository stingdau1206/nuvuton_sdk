# Keil uVision project WDT_Reset.uvproj, settings and files
target WDT (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: WDT_disable +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: WDT_reset.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c watchdog.c delay.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
